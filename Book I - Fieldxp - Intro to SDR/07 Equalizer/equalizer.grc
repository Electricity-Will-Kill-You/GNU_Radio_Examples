options:
  parameters:
    generate_options: qt_gui
    id: equalizer
    output_language: python
    title: Equalizer
  states: {}

blocks:
- name: Base
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: KILO
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: Mid
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: Trebel
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Base
    high_cutoff_freq: '400'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Mid
    high_cutoff_freq: 2.6*KILO
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Trebel
    high_cutoff_freq: 10*KILO
    low_cutoff_freq: 2.6*KILO
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\senti\Desktop\github\GNU_Radio\Book I - Fieldxp - Intro to SDR\07 Equalizer\HumanEvents_s32k.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"dark red"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
