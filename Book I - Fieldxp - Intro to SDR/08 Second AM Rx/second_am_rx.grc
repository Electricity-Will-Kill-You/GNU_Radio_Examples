options:
  parameters:
    generate_options: qt_gui
    id: second_am_rx
    output_language: python
    title: second am rx
  states: {}

blocks:
- name: KILO
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: KILO
    step: KILO
    stop: 1000*KILO
    value: 900*KILO
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: KILO
    step: KILO
    stop: 1000*KILO
    value: 880*KILO
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\senti\Desktop\github\GNU_Radio\Book I - Fieldxp - Intro to SDR\08 Second AM Rx\am_broadcast_02_c900k_s400k.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"AM Input"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"dark red"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Multiply Output"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '400'
    interp: '32'
    type: fff
  states: {}

connections:
- [analog_am_demod_cf_0, '0', qtgui_freq_sink_x_2, '0']
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
