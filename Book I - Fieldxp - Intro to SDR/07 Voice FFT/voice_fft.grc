options:
  parameters:
    generate_options: qt_gui
    id: voice_fft
    output_language: python
    title: voice fft
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\senti\Desktop\MyGNU Radio\03 FFT\HumanEvents_s32k.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    norm_window: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
